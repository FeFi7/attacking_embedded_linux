do_install:append() {
        chmod 777 ${D}/www/pages  
}

